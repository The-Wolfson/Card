File: PCB/Card.kicad_pcb (KiCad board)
At the start: 2 copper layers, 85 x 54 mm, 7 parts, among them U1 NT3H2111W0FHKH

Commit message: updated PCB
Routing:
- net (no net): track 3182.4 -> 261.8 mm
